Commit message: add w-p3

File: atom-w-p3/urdf/atom-w-p3.urdf (robot description, URDF)
Before this commit: robot atom_w_p3, 23 links, 22 joints
Joints:
- joint left_shoulder_roll_joint: axis 0 1 0 -> 1 0 0
